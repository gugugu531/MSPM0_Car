# Keil uVision project NUEDC2025_MSPM0G3507.uvprojx, settings and files
target NUEDC2025_MSPM0G3507 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUEDC2025_MSPM0G3507 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: C:\ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;C:\ti\mspm0_sdk_2_10_00_04\source;..\..\Core\Inc;..\..\Core\Src;..\..\Board\SysConfig;..\..\drivers;..\..\drivers\Platform\Common;..\..\drivers\Platform\System;..\..\drivers\BSP\Imu;..\..\drivers\BSP\Key;..\..\drivers\BSP\Laser;..\..\drivers\BSP\Motor;..\..\drivers\BSP\OLED;..\..\drivers\BSP\StepMotor;..\..\drivers\BSP\TrackingSensor;..\..\Modules\Control;..\..\Modules\Mission
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: ROM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20200000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ..\..\Board\Startup\mspm0g3507.sct
  group Core/Src
    ../../Core/Src/: main.c
  group Board/SysConfig
    ../../Board/SysConfig/: ti_msp_dl_config.c
  group Board/Startup
    C:/ti/mspm0_sdk_2_10_00_04/source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
  group Drivers/Platform
    ../../drivers/Platform/System/: Delay.c ErrorHandler.c Initialize.c InitStepMotor.c
  group Modules/Control
    ../../Modules/Control/: Pid.c Kinematics.c Rotation.c Tracking.c SensorProc.c StepMotorCtrl.c
  group Modules/Mission
    ../../Modules/Mission/: AppLauncher.c Mode.c Menu.c ModeTree.c CircleList.c
  group Drivers/BSP
    ../../drivers/BSP/Motor/: Tb6612fng.c HallEncoder.c
    ../../drivers/BSP/OLED/: Oled.c
    ../../drivers/BSP/Key/: Key.c
    ../../drivers/BSP/Laser/: LaserUsart.c
    ../../drivers/BSP/StepMotor/: StepMotor.c
    ../../drivers/BSP/TrackingSensor/: TrackingSensor.c
    ../../drivers/BSP/Imu/: WitSdk.c
  group Driverlib
    C:/ti/mspm0_sdk_2_10_00_04/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
