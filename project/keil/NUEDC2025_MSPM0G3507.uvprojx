# Keil uVision project NUEDC2025_MSPM0G3507.uvprojx, settings and files
target NUEDC2025_MSPM0G3507 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUEDC2025_MSPM0G3507 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..;..\..\app;..\..\core;..\..\core\common;..\..\core\filter;..\..\core\kinematics;..\..\core\pid;..\..\middleware\chassis;..\..\middleware\fault;..\..\middleware\line_follow;..\..\middleware\straight_drive;..\..\middleware\ui;..\..\bsp\common;..\..\bsp\bluetooth;..\..\bsp\debug_uart;..\..\bsp\grayscale_sensor;..\..\bsp\ganv_gray;..\..\bsp\imu;..\..\bsp\key;..\..\bsp\motor;..\..\bsp\oled;..\..\bsp\time;..\..\bsp\mpu6050;..\..\board\sys_config;..\..\third_party\mspm0-sdk\source;..\..\third_party\mspm0-sdk\source\third_party\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20200000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ..\..\board\startup\mspm0g3507.sct
  group App
    ../../app/: main.c app_init.c app_scheduler.c app_mode.c app_checks.c app_line_task.c app_straight_task.c app_bt_task.c app_menu.c app_menu_def.c app_fmt.c
  group driverlib
    ../../third_party/mspm0-sdk/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group Core
    ../../core/kinematics/: kinematics.c
    ../../core/pid/: pid.c
    ../../core/filter/: filter.c
  group MiddleWare
    ../../middleware/chassis/: chassis.c
    ../../middleware/fault/: system_fault.c
    ../../middleware/line_follow/: line_follow.c
    ../../middleware/straight_drive/: straight_drive.c
    ../../middleware/ui/: ui.c
  group Board
    ../../board/startup/: startup_mspm0g350x_uvision.s
    ../../board/sys_config/: ti_msp_dl_config.c G3507.syscfg
  group BSP
    ../../bsp/bluetooth/: bluetooth.c
    ../../bsp/debug_uart/: debug_uart.c
    ../../bsp/grayscale_sensor/: grayscale_sensor.c
    ../../bsp/ganv_gray/: ganv_gray.c
    ../../bsp/imu/: wit_sdk.c
    ../../bsp/key/: key.c
    ../../bsp/motor/: hall_encoder.c tb6612fng.c
    ../../bsp/oled/: oled.c
    ../../bsp/time/: bsp_time.c
    ../../bsp/mpu6050/: mpu6050.c mpu6050_dmp_fw.c mpu6050_test.c
